# Keil uVision project main.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.52.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x12000000,0x08000000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: main +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 wLevel=1
  c define: BOARD_PCA10056,CONFIG_GPIO_AS_PINRESET ARM_MATH_DSP ARM_MATH_DSP CMSIS_NN
  c include: ..\..\drive;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\boards;..\..\components\libraries\balloc;..\..\components\libraries\util;..\..\components\libraries\atomic;..\..\components\libraries\balloc;..\..\components\libraries\bsp;..\..\components\libraries\delay;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\log\src;..\..\components\libraries\memobj;..\..\components\libraries\ringbuf;..\..\components\libraries\strerror;..\..\components\libraries\util;..\..\integration\nrfx;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\config;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\drivers\src\prs;..\..\modules\nrfx\drivers;..\..\modules\nrfx\templates;..\..\modules\nrfx\soc;..\..\modules\nrfx\mdk;..\..\components\libraries\log;..\..\integration\nrfx\legacy;..\..\components\boards;..\..\config\nrf52840\config;..\..\modules\nrfx\drivers\src;..\..\components\libraries\fifo;..\..\components\libraries\uart;.\fft;..\..\CMSIS-DSP\1.14.4\Include;..\..\CMSIS-DSP\1.14.4\Include\dsp;..\..\components\libraries\log\;..\..\TFLM_CMSIS_NN;..\..\TFLM_CMSIS_NN\tensorflow\lite\micro\tools\make\downloads\ruy;..\ble_peripheral;.\third_party\gemmlowp;.\third_party\flatbuffers\include;C:\Keil_V5\ARM\ARMCLANG\include\libcxx;.\clustering;..\..\TFLM_CMSIS_NN\tensorflow\lite\micro\tools\make\downloads\cmsis_nn\Include\;..\..\TFLM_CMSIS_NN\tensorflow\lite\micro\tools\make\downloads\cmsis_nn\;.\feature_extraction
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x12000000 size 0x8000000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  scatter file: .\Objects\main.sct
  group main
    ./: main.cc raw_rcc_data_x_pre_process.h raw_rcc_data_x_pre_process.c
    ../../config/nrf52840/config/: sdk_config.h
    Z:/tflite-micro/tensorflow/lite/micro/: micro_log.cc micro_interpreter.cc micro_interpreter_graph.cc micro_op_resolver.cc micro_interpreter_context.cc debug_log.cc micro_allocator.cc flatbuffer_utils.cc micro_context.cc micro_resource_variable.cc memory_helpers.cc micro_allocation_info.cc
    Z:/tflite-micro/tensorflow/lite/core/api/: flatbuffer_conversions.cc error_reporter.cc
    Z:/tflite-micro/tensorflow/lite/schema/: schema_utils.cc
    Z:/tflite-micro/tensorflow/lite/micro/tflite_bridge/: flatbuffer_conversions_bridge.cc
    Z:/tflite-micro/tensorflow/lite/kernels/internal/: portable_tensor_utils.cc
    Z:/tflite-micro/tensorflow/lite/core/c/: common.cc
    Z:/tflite-micro/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc
    Z:/tflite-micro/tensorflow/lite/micro/arena_allocator/: persistent_arena_buffer_allocator.cc non_persistent_arena_buffer_allocator.cc single_arena_buffer_allocator.cc
    Z:/tflite-micro/bazel-tflite-micro/tensorflow/lite/kernels/internal/: tensor_ctypes.cc
    Z:/tflite-micro/bazel-tflite-micro/tensorflow/lite/micro/: micro_utils.cc
    Z:/tflite-micro/bazel-tflite-micro/tensorflow/lite/core/api/: error_reporter.h
    Z:/tflite-micro/bazel-tflite-micro/tensorflow/lite/micro/tflite_bridge/: micro_error_reporter.cc
  group drive
    ../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c
    ../../integration/nrfx/legacy/: nrf_drv_uart.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ./: led.c
  group lib
    ../../components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/fifo/: app_fifo.c
  group Board Definition
    ../../components/boards/: boards.c
  group DSP/FFT
    ./fft/src/asm/arm/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s
    ./fft/inc/: table_fft.h
    ./fft/: FFT_instance.c FFT_instance.h
    C:/Keil_V5/ARM/PACK/ARM/CMSIS-DSP/1.14.4/Source/WindowFunctions/: WindowFunctions.c
  group Clustering
    ./clustering/: fcm_method.cc fcm_method.h
  group Feature Extraction
    ./feature_extraction/: features_extraction.c features_extraction.h filtering_preprocessing.c filtering_preprocessing.h hilbert_and_envelope_signal.c hilbert_and_envelope_signal.h integration.c integration.h frequency_integral.h frequency_integral.c
  group Fault Diagnosis
    ./fault_diagnosis/: common_internal.cc constants.cc constants.h kernel_util.cc main_functions.cc main_functions.h micro_kernel_util.cc model_keras_to_tflite.cc model_keras_to_tflite.h svm_params.c svm_params.h Gaussian_bayes.h Gaussian_bayes.c confusion_matrix_and_metrics.c confusion_matrix_and_metrics.h
  group TFLM Kernels
    Z:/tflite-micro/tensorflow/lite/kernels/internal/: quantization_util.cc
    Z:/tflite-micro/tensorflow/lite/micro/kernels/: reshape_common.cc reshape.cc dequantize_common.cc quantize_common.cc dequantize.cc quantize.cc conv_common.cc depthwise_conv_common.cc fully_connected_common.cc pooling_common.cc softmax_common.cc
    Z:/tflite-micro/tensorflow/lite/micro/kernels/cmsis_nn/: add.cc mul.cc conv.cc depthwise_conv.cc fully_connected.cc pooling.cc softmax.cc
    ../../TFLM_CMSIS_NN/tensorflow/lite/micro/kernels/: add_common.cc mul_common.cc
  group CMSIS NN
    Z:/tflite-micro/tensorflow/lite/micro/tools/make/downloads/cmsis_nn/Source/ConvolutionFunctions/: arm_depthwise_conv_get_buffer_sizes_s4.c arm_depthwise_conv_get_buffer_sizes_s8.c arm_depthwise_conv_s16.c arm_depthwise_conv_wrapper_s4.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_conv_s4_opt.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_s4.c arm_convolve_s4.c arm_convolve_1x1_s8_fast.c arm_convolve_get_buffer_sizes_s8.c arm_convolve_get_buffer_sizes_s16.c arm_convolve_wrapper_s4.c arm_convolve_wrapper_s8.c arm_convolve_wrapper_s16.c arm_convolve_1x1_s4_fast.c arm_convolve_1_x_n_s8.c arm_convolve_1x1_s4.c arm_convolve_fast_s16.c arm_convolve_s8.c arm_convolve_s16.c arm_convolve_1x1_s8.c arm_nn_mat_mult_kernel_s4_s16.c arm_nn_mat_mult_kernel_s8_s16.c
    Z:/tflite-micro/tensorflow/lite/micro/tools/make/downloads/cmsis_nn/Source/FullyConnectedFunctions/: arm_fully_connected_get_buffer_sizes_s8.c arm_fully_connected_get_buffer_sizes_s16.c arm_fully_connected_s4.c arm_fully_connected_s8.c arm_fully_connected_s16.c arm_vector_sum_s8.c
    Z:/tflite-micro/tensorflow/lite/micro/tools/make/downloads/cmsis_nn/Source/PoolingFunctions/: arm_avgpool_get_buffer_sizes_s8.c arm_avgpool_get_buffer_sizes_s16.c arm_avgpool_s8.c arm_avgpool_s16.c arm_max_pool_s8.c arm_max_pool_s16.c
    Z:/tflite-micro/tensorflow/lite/micro/tools/make/downloads/cmsis_nn/Source/SoftmaxFunctions/: arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_s16.c arm_nn_softmax_common_s8.c
    Z:/tflite-micro/tensorflow/lite/micro/tools/make/downloads/cmsis_nn/Source/NNSupportFunctions/: arm_nn_mat_mult_nt_t_s8.c arm_nn_mat_mult_nt_t_s4.c arm_nn_mat_mul_kernel_s16.c arm_nn_vec_mat_mult_t_s4.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_s16.c arm_q7_to_q15_with_offset.c arm_s8_to_s16_unordered_with_offset.c
    ../../TFLM_CMSIS_NN/tensorflow/lite/micro/tools/make/downloads/cmsis_nn/Source/BasicMathFunctions/: arm_elementwise_mul_s8.c arm_elementwise_mul_s16.c arm_elementwise_add_s8.c arm_elementwise_add_s16.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.4, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Device:Startup 8.52.0
